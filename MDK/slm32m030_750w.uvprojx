# Keil uVision project slm32m030_750w.uvprojx, settings and files
target Project (6160000::V6.16::ARMCLANG)
  device: SLM32M030CCT7 SoulSemi
  pack: SoulSemi.SLM32X030_DFP.1.0.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: slm32m030_750w +hex
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe $PObjects\%L --disassemble --interleave=source --text -c --output=.\Listings\full_disasm.lst
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER
  c include: ..\User\Inc;..\..\slm32m030_750w;..\Modules\Inc;..\Middle\modbus\freemodbus\modbus\include;..\Middle\modbus\freemodbus\modbus\rtu;..\Drives\CMSIS\Include;..\Drives\CMSIS\Device\SoulSemi\SLM32X030\Include;..\Drives\SATURN13;..\Drives\SLM32X030_HAL_Driver\Inc;..\Bsp\Inc;..\Core\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --info=stack
  group Main
    ../: main.c slm32m030_it.c user_board.h user_control.h
  group MDK-ARM
    ../Drives/CMSIS/Device/SoulSemi/SLM32X030/Source/: system_slm32x030.c
    ../Drives/CMSIS/Device/SoulSemi/SLM32X030/Source/ARM/: startup_slm32x030.s
  group Drivers/SLM32F0xx_HAL_Driver
    ../Drives/SLM32X030_HAL_Driver/Src/: slm32x030_hal.c slm32x030_hal_adc.c slm32x030_hal_awk.c slm32x030_hal_beep.c slm32x030_hal_cortex.c slm32x030_hal_crc.c slm32x030_hal_dma.c slm32x030_hal_exti.c slm32x030_hal_flash.c slm32x030_hal_flash_ex.c slm32x030_hal_gpio.c slm32x030_hal_i2c.c slm32x030_hal_iwdg.c slm32x030_hal_lptim.c slm32x030_hal_lpuart.c slm32x030_hal_lvd.c slm32x030_hal_pmu.c slm32x030_hal_rcmu.c slm32x030_hal_rcmu_ex.c slm32x030_hal_rtc.c slm32x030_hal_spi.c slm32x030_hal_spi_ex.c slm32x030_hal_syscfg.c slm32x030_hal_tim.c slm32x030_hal_tim_ex.c slm32x030_hal_trng.c slm32x030_hal_usart.c slm32x030_hal_vc.c slm32x030_hal_wwdg.c
  group Middle/Modbus
    ../Middle/modbus/freemodbus/modbus/: mb.c
    ../Middle/modbus/freemodbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../Middle/modbus/freemodbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncfile.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Core
    ../Core/lib/: libmc_core.a libmc_super.a
  group Bsp
    ../Bsp/Src/: ad.c afe.c beep.c gpio.c iwdg.c rf.c spi.c tim.c uart.c portevent.c portserial.c porttimer.c port.c
  group Modules
    ../Modules/Src/: cmdbus.c fault.c foc.c ntc.c
  group User
    ../User/Src/: modbus_task.c poke_task.c main_task.c
